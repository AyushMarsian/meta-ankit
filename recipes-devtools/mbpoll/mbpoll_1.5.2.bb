
include mbpoll.inc

SRC_URI = "https://github.com/epsilonrt/mbpoll/archive/refs/tags/v1.5.2.tar.gz"
SRC_URI[md5sum] = "9ecf25987a918b86a716c8d79ee01132"
SRC_URI[sha256sum] = "7d960cd4459b5f7c2412abc51aba93a20b6114fd75d1de412b1e540cfb63bfec"

S = "${WORKDIR}/mbpoll-1.5.2"


